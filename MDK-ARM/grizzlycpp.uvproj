# Keil uVision project grizzlycpp.uvproj, settings and files
target GrizzlyBoard (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: grizzlycpp
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F40XX
  c include: ..\inc;..\libs\CMSIS\Include;..\libs\CMSIS\Device\ST\STM32F4xx\Include;..\libs\STM32F4xx_StdPeriph_Driver\inc;..\libs\STM32F4x7_ETH_Driver\inc;..\libs\GrizzlyBSP\inc;..\libs\lwip-1.4.1\src\include;..\libs\lwip-1.4.1\src\include\lwip;..\libs\lwip-1.4.1\src\include\netif;..\libs\lwip-1.4.1\src\include\ipv4;..\libs\lwip-1.4.1\port\STM32F4x7;..\libs\lwip-1.4.1\port\STM32F4x7\Standalone
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../libs/GrizzlyBSP/src/: system_stm32f4xx.c
  group LwIP
    ../libs/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../libs/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../libs/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../libs/lwip-1.4.1/src/netif/: etharp.c slipif.c
    ../libs/lwip-1.4.1/port/STM32F4x7/Standalone/: ethernetif.c
  group BSP
    ../libs/GrizzlyBSP/src/: stm32f4x7_eth_bsp.c netconf.c startup_stm32f4xx.s
    ../libs/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ../libs/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group main
    ../src/: dma_conf.c fifobufs.c fifobufs_iram1.c fifobufs_iram2.c frame_helpers.c gpio_conf.c interleave_lut.c main.c stm32f4xx_it.c sys_conf.c udp_colorserver.c udp_debugclient.c udp_echoserver.c workers.c
